# Keil uVision project usbaudio.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: usbaudio +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\common\inc;.\common\src
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\DMA.sct
  group Source Files
    ./: usbuser.c usbcore.c usbdesc.c usbhw.c adcuser.c LPC17xx.h GLCD_SPI_LPC1700.c IRQ.c LED.c KBD.c usbdmain.c MP3.c game.c game.h photos.c
  group Startup Files
    ./: system_LPC17xx.c core_cm3.c startup_LPC17xx.s
  group New Group
    ./: boulder.c rock.c hole.c rock_in.c player.c empty.c greninja.c charizard.c torterra.c
software components: CMSIS:CORE 5.4.0
